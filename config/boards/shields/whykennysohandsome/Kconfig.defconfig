## config/boards/shields/whykennysohandsome/Kconfig.shield
```kconfig
config SHIELD_WHYKENNYSO
    def_bool $(shields_list_contains,WhyKennySoHandsome)
```
